options:
  parameters:
    author: Marc Lichtman
    generate_options: qt_gui
    id: pn11_over_difi_rx
    output_language: python
    title: PN11 Over DIFI Rx
  states: {}

blocks:
- name: constellation_obj
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      symbol sync likes the
      signal to be close to -1 to +1
    const: 1/127
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '21'
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: difi_source_cpp_0_0
  id: difi_source_cpp
  parameters:
    bit_depth: '8'
    context_behavior: '0'
    ip_addr: 127.0.0.1
    port: '50003'
    protocol: '2'
    stream_num: '0'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_obj
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    minoutbuf: '10000000'
    order: '4'
    w: '0.06'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, samples=1000):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Print first N samples',
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              self.samples = samples
              self.i = 0

          def work(self, input_items, output_items):
              if self.i < self.samples:
                  N = min(self.samples - self.i, len(input_items[0]))
                  print(input_items[0][0:N])
                  self.i += N
                  return N
              else:
                  return len(input_items[0])
    samples: '100'
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\ndef pn11_gen(seed, length):\n    reg = [int(x) for x in f\"{seed:011b}\"]\n    output = []\n    for _ in range(length):\n        output_bit = reg[-1]\n        output.append(output_bit)\n        # Feedback using taps at positions 11 and 9 (indexes 10 and 8)\n        feedback = reg[10] ^ reg[8]\n        # Shift left and insert feedback at the beginning\n        reg = [feedback] + reg[:-1]\n    return np.asarray(output)\n\nclass pn11_ber(gr.basic_block):\n    def __init__(self, seed=1, threshold=0.9):\n        gr.basic_block.__init__(\n            self,\n            name='PN11 Sync',\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        self.pn_length = 2047  # Length of PN11 sequence: 2^11 - 1\n        self.seq = pn11_gen(seed=seed, length=self.pn_length*2)\n        self.synced = False\n        self.phase_shift = 0\n        self.temp_count = 0\n        self.wait_n_samps = 10000\n        self.wait_i = 0\n        self.waiting = True\n\n        self.nbits = 0.0\n        self.nerrs = 0.0\n        self.seq_i = 0\n        self.n_calls = 0\n        \n        self.corr_thresh = threshold\n  \n        # QPSK Demod\n        self.bit_mapping = {\n            (-1-1j): [0, 0],\n            (1-1j):  [0, 1],\n            (-1+1j): [1, 0],\n            (1+1j):  [1, 1],\n        }\n        #self.bit_mapping = {\n        #    (-1-1j): [0, 0],\n        #    (1-1j):  [1, 0],\n        #    (-1+1j): [0, 1],\n        #    (1+1j):  [1, 1],\n        #} \n            \n        # Craft search preamble\n        self.qpsk_mapping = np.asarray([-1-1j, 1-1j, -1+1j, 1+1j], dtype=np.complex64)\n        self.search_preamble = np.zeros(self.pn_length//2, dtype=np.complex64)\n        for i in range(self.pn_length//2):\n            self.search_preamble[i] = self.qpsk_mapping[self.seq[i*2] + self.seq[i*2+1]*2]\n\n\n    def general_work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n        N = len(out)\n        \n        if self.waiting:\n            self.wait_i += N\n            if self.wait_i > self.wait_n_samps:\n                self.waiting = False\n            self.consume(0, N)\n            return 0\n        \n        if not self.synced:\n            if N <= self.pn_length: # need more samples\n                return 0\n            max_corr = 0\n            for i in range(N - self.pn_length//2):\n                corr = np.abs(np.dot(input_items[0][i:i+self.pn_length//2], self.search_preamble)) / (self.pn_length//2)\n                # With QPSK there's actually no need to check all 4 rotations, rotating doesnt change the abs(corr(dot()))\n                if corr > max_corr:\n                    max_corr = corr\n                if corr > self.corr_thresh:\n                    #print(\"Synced! at index\", i)\n                    #print(\"self.temp_count\", self.temp_count)\n                    self.synced = True\n                    self.seq_i = 0 # important!\n                    \n                    # Note that the act of calculating these and printing was causing an overflow and leading to it never staying synced\n                    #phase_diff = np.mean(np.angle(input_items[0][i:i+self.pn_length//2] * np.conj(self.search_preamble)))\n                    #closest = min([0, np.pi / 2, np.pi, 3 * np.pi / 2, 2 * np.pi], key=lambda t: abs(phase_diff - t))\n                    #self.phase_shift = np.exp(1j*closest)\n\n                    #print(\"Phase shift:\", self.phase_shift) # first one is always 1+0j\n                    # I think what's happening is there ends up never being a 1 bit shift because of the number of samples per difi packet\n                    #print(input_items[0][i:i+10] * -1 * self.phase_shift)\n                    self.consume(0, i) # drop the samples right before the spike\n                    return 0\n            #print(\"No sync found, max corr:\", max_corr)\n            self.consume(0, N - self.pn_length//2) # discard the samples we put through the correlator with no match\n            self.temp_count += N - self.pn_length//2\n            return 0\n            \n        else: # Demod and calc BER but also output the IQ samples for any further downstream processing\n            n = min(len(in0), N, len(self.seq)//2)\n            n = n - (n % 2) # force it to be even\n            if n < 50:\n                return 0 # want more to be able to tell BER is crap in just 1 call to work\n            \n            demod_bits = []\n            for s in in0[:n//2]: # to produce n bits\n                distances = np.abs(self.qpsk_mapping - s)\n                nearest_index = np.argmin(distances)\n                nearest_symbol = self.qpsk_mapping[nearest_index]\n                bits = self.bit_mapping[nearest_symbol]\n                demod_bits.extend(bits)\n            demod_bits = np.array(demod_bits, dtype=np.uint8)\n\n            # Calculate errors and bits processed\n            sub_seq = self.seq[self.seq_i:self.seq_i + n]\n            self.seq_i += n\n            self.seq_i %= self.pn_length\n            current_nerrs = np.sum(np.bitwise_xor(demod_bits, sub_seq).astype('float32'))\n            self.nerrs += current_nerrs\n            if current_nerrs / n > 0.5:\n                #print(\"High BER, resyncing!\")\n                self.synced = False\n            self.nbits += n\n            self.n_calls += 1\n            if self.n_calls > 1000: # too many prints otherwise, will slow down GR\n                print(f\"NBits: {int(self.nbits)} \\tNErrs: {int(self.nerrs)} \\tBER: {self.nerrs / self.nbits:.6f}\")\n                self.n_calls = 0\n\n            out[:n//2] = in0[:n//2] # * self.phase_shift\n            self.consume(0, n//2)\n            return n//2\n        \n        \n"
    minoutbuf: '4000'
    seed: '1'
    threshold: '0.9'
  states: {}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\ndef pn11_gen(seed, length):\n    reg = [int(x) for x in f\"{seed:011b}\"]\n    output = []\n    for _ in range(length):\n        output_bit = reg[-1]\n        output.append(output_bit)\n        # Feedback using taps at positions 11 and 9 (indexes 10 and 8)\n        feedback = reg[10] ^ reg[8]\n        # Shift left and insert feedback at the beginning\n        reg = [feedback] + reg[:-1]\n    return np.asarray(output)\n\nclass pn11_ber(gr.sync_block):\n    def __init__(self, seed=1):\n        gr.sync_block.__init__(\n            self,\n            name='PN11 BER',\n            in_sig=[np.uint8],\n            out_sig=[]\n        )\n        self.nbits = 0.0\n        self.nerrs = 0.0\n        self.i = 0\n        self.n_calls = 0\n        self.pn_length = 2047  # Length of PN11 sequence: 2^11 - 1\n        self.seq = pn11_gen(seed=seed, length=self.pn_length*2)\n        self.synced = False\n        self.search_size = 2047\n        self.corr_thresh = 100.0\n        \n        # Craft search preamble\n        qpsk_mapping = np.asarray([-1-1j, 1-1j, -1+1j, 1+1j], dtype=np.complex64)\n        self.search_preamble = np.zeros(self.search_size, dtype=np.complex64)\n        for i in range(self.search_size):\n            self.search_preamble[i] = qpsk_mapping[self.seq[i*2]*2 + self.seq[i*2+1]]\n\n\n    def work(self, input_items, output_items):\n        N = min(len(input_items[0]), self.pn_length)\n        sub_seq = self.seq[self.i:self.i + N]\n        self.i += N\n        self.i %= self.pn_length\n\n        # Calculate errors and bits processed\n        self.nerrs += np.sum(np.bitwise_xor(input_items[0][0:N], sub_seq).astype('float32'))\n        self.nbits += N\n        self.n_calls += 1\n        if self.n_calls > 100: # too many prints otherwise, will slow down GR\n            print(f\"NBits: {int(self.nbits)} \\tNErrs: {int(self.nerrs)} \\tBER: {self.nerrs / self.nbits:.6f}\")\n            self.n_calls = 0\n\n        return N\n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n\n"
    seed: '1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 40e6
    fc: 2.4e9
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,2
    legend: 'False'
    showports: 'True'
    type: complex
    ymax: '-25'
    ymin: '-60'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: I
    label2: Q
    marker1: '0'
    marker2: '0'
    size: '100'
    srate: '1'
    type: complex
    update_time: '0.20'
  states: {}

connections:
- [blocks_multiply_const_vxx_0_0, '0', blocks_probe_rate_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_skiphead_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_4_0, '0']
- [difi_source_cpp_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [difi_source_cpp_0_0, '0', epy_block_2, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_skiphead_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_4, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_4, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
