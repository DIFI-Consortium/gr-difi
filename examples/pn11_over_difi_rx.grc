options:
  parameters:
    author: Marc Lichtman
    generate_options: qt_gui
    id: pn11_over_difi_rx
    output_language: python
    title: PN11 Over DIFI Rx
  states: {}

blocks:
- name: constellation_obj
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      symbol sync likes the
      signal to be close to -1 to +1
    const: 1/127
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '42'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: difi_source_cpp_0_0
  id: difi_source_cpp
  parameters:
    bit_depth: '8'
    context_behavior: '0'
    ip_addr: 127.0.0.1
    port: '50003'
    protocol: '1'
    stream_num: '0'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_obj
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    comment: |-
      00 -> -1-1j
      01 -> 1-1j
      10 -> -1+1j
      11 -> 1+1j
    mark_delay: '0'
    sps: '4'
    symbols: '[-1+1j, -1-1j, -1-1j, -1-1j, -1-1j, 1-1j, -1-1j, -1-1j, -1-1j, -1-1j, -1+1j, -1+1j]'
    threshold: '0.999'
    threshold_method: digital.THRESHOLD_DYNAMIC
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.06'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, samples=1000):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Print first N samples',
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              self.samples = samples
              self.i = 0

          def work(self, input_items, output_items):
              if self.i < self.samples:
                  N = min(self.samples - self.i, len(input_items[0]))
                  print(input_items[0][0:N])
                  self.i += N
                  return N
              else:
                  return len(input_items[0])
    samples: '100'
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      def pn11_gen(seed, length):
          reg = [int(x) for x in f"{seed:011b}"]
          output = []
          for _ in range(length):
              output_bit = reg[-1]
              output.append(output_bit)
              # Feedback using taps at positions 11 and 9 (indexes 10 and 8)
              feedback = reg[10] ^ reg[8]
              # Shift left and insert feedback at the beginning
              reg = [feedback] + reg[:-1]
          return np.asarray(output)

      class pn11_ber(gr.sync_block):
          def __init__(self, seed=1):
              gr.sync_block.__init__(
                  self,
                  name='PN11 BER',
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.nbits = 0.0
              self.nerrs = 0.0
              self.i = 0
              self.n_calls = 0
              self.pn_length = 2047  # Length of PN11 sequence: 2^11 - 1
              
              '''
              # Generate PN11 sequence twice so that we dont have to wrap around
              # (each call to work we will process at most pn_length bits)
              self.seq = np.zeros(self.pn_length * 2, dtype=np.uint8)
              reg = seed  # seed (non-zero 11-bit integer)
              for i in range(self.pn_length * 2):
                  self.seq[i] = (reg >> 10) & 1
                  bit_11 = (reg >> 10) & 0x01
                  bit_9 = (reg >> 8) & 0x01
                  new_bit = bit_11 ^ bit_9
                  reg = ((reg << 1) & 0x7FF) | new_bit
              '''
              self.seq = pn11_gen(seed=seed, length=self.pn_length*2)
              
              # sanity check
              print(self.seq[0:20])
              print(self.seq[2047:2067])

          def work(self, input_items, output_items):
              N = min(len(input_items[0]), self.pn_length)
              sub_seq = self.seq[self.i:self.i + N]
              self.i += N
              self.i %= self.pn_length

              # Calculate errors and bits processed
              self.nerrs += np.sum(np.bitwise_xor(input_items[0][0:N], sub_seq).astype('float32'))
              self.nbits += N
              self.n_calls += 1
              if self.n_calls > 1000: # too many prints otherwise, will slow down GR
                  print(f"NBits: {int(self.nbits)} \tNErrs: {int(self.nerrs)} \tBER: {self.nerrs / self.nbits:.6f}")
                  self.n_calls = 0

              return N
    seed: '1'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 40e6
    fc: 2.4e9
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,2
    legend: 'False'
    showports: 'True'
    type: complex
    ymax: '-25'
    ymin: '-60'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: I
    label2: Q
    marker1: '0'
    marker2: '0'
    size: '100'
    srate: '1'
    type: complex
    update_time: '0.20'
  states: {}

connections:
- [blocks_multiply_const_vxx_0_0, '0', blocks_probe_rate_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_skiphead_0, '0', epy_block_4, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_skiphead_0, '0']
- [difi_source_cpp_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [difi_source_cpp_0_0, '0', epy_block_2, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
