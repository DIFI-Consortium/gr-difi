options:
  parameters:
    author: Marc Lichtman
    generate_options: qt_gui
    id: pn11_over_difi_rx
    output_language: python
    title: PN11 Over DIFI Rx
  states: {}

blocks:
- name: constellation_obj
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      symbol sync likes the
      signal to be close to -1 to +1
    const: 1/45
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '42'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: difi_source_cpp_0_0
  id: difi_source_cpp
  parameters:
    bit_depth: '16'
    context_behavior: '0'
    ip_addr: 127.0.0.1
    port: '50003'
    protocol: '1'
    stream_num: '0'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_obj
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.06'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, samples=1000):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Print first N samples',
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              self.samples = samples
              self.i = 0

          def work(self, input_items, output_items):
              if self.i < self.samples:
                  N = min(self.samples - self.i, len(input_items[0]))
                  print(input_items[0][0:N])
                  self.i += N
                  return N
              else:
                  return len(input_items[0])
    samples: '100'
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PN11 BER',
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.nbits = 0.0
              self.nerrs = 0.0
              self.i = 0
              self.reg = 0x400 # seed, must be a non-zero 11-bit integer (1 to 2046)

          def work(self, input_items, output_items):
              inb = input_items[0]
              gen = np.zeros(len(inb), dtype=np.uint8)
              for i in range(len(inb)):
                  #gen[i] = self.reg & 0x01  # Output LSB
                  gen[i] = (self.reg >> 10) & 1

                  # Feedback = XOR of bit 11 and bit 9
                  bit_11 = (self.reg >> 10) & 0x01
                  bit_9 = (self.reg >> 8) & 0x01
                  new_bit = bit_11 ^ bit_9

                  # Shift register: shift right and insert new bit at MSB
                  #self.reg = ((self.reg >> 1) | (new_bit << 10)) & 0x7FF  # Mask to 11 bits
                  self.reg = ((self.reg << 1) & 0x7FF) | new_bit
              
              
              self.nerrs += np.sum(np.bitwise_xor(inb, gen).astype('float32'))
              self.nbits += len(inb)
              self.i += 1
              if self.nbits > 0 and self.i > 100:
                  print("NBits: %d \tNErrs: %d \tBER: %f"%(int(self.nbits), int(self.nerrs), self.nerrs/self.nbits))
                  self.i = 0
              return len(inb)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,2
    legend: 'False'
    type: complex
    ymax: '-25'
    ymin: '-60'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: I
    label2: Q
    marker1: '0'
    marker2: '0'
    size: '100'
    srate: samp_rate
    type: complex
    update_time: '0.20'
  states: {state: disabled}

connections:
- [blocks_multiply_const_vxx_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_skiphead_0, '0', epy_block_4, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_skiphead_0, '0']
- [difi_source_cpp_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [difi_source_cpp_0_0, '0', epy_block_2, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
